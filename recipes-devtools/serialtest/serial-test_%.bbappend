SRC_URI = "git://github.com/ci4rail/linux-serial-test.git;branch=master;protocol=https"
SRCREV = "d3ab050d55c57c3e82a3dbdefeee41d6cdb84bbd"
